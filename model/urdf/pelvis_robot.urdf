Commit message: updated pelvis bot to rotate about a single axis

File: model/urdf/pelvis_robot.urdf (robot description, URDF)
Before this commit: robot pelvisRobot, 4 links, 3 joints
Joints:
- joint fakeJoint2: axis 0 1 0 -> 1 0 0
- joint rootJoint: axis 0 1 0 -> 1 0 0; type revolute -> fixed
