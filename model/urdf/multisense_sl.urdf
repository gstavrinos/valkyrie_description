Commit message: removing imu link from multisense

File: model/urdf/multisense_sl.urdf (robot description, URDF)
Before this commit: robot multisense_sl, 12 links, 11 joints
Links:
- removed link multisense/head_imu_link
Joints:
- removed joint head_imu_joint
